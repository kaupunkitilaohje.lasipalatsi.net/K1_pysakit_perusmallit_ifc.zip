Properties of the parts of a building model (IFC2X3)

# File
Description: IFC 2x3 Building Model
Time: 2021-12-28T16:05:29
Author: Vaarna, Verna
Organization: WSP
Made in: ASIFC - 2.11.0.854

# IfcSite
RefElevation: 0 mm

# IfcProxy (649)
ProxyType: PRODUCT
